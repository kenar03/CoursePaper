# IAR project iarproject.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: Rtos; Rtos\wrapper; Rtos\wrapper\FreeRtos; Rtos\FreeRtos; Rtos\FreeRtos\include; Rtos\FreeRtos\portable; Rtos\FreeRtos\portable\Common; Rtos\FreeRtos\portable\IAR; Rtos\FreeRtos\portable\IAR\ARM_CM4F; Rtos\FreeRtos\portable\MemMang; MyTasks; Common; CMSIS; Application; Application\Diagnostic; AHardware; AHardware\GpioPort; AHardware\IrqController; ..\CortexLib\AbstractHardware\Pin; ..\CortexLib\AbstractHardware\Registers\STM32F411\FieldValues; ..\CortexLib\AbstractHardware\Registers\STM32F411; ..\CortexLib\AbstractHardware\Registers; ..\CortexLib\AbstractHardware\Port; ..\CortexLib\AbstractHardware\Atomic; ..\CortexLib\Common; ..\CortexLib\Common\Singleton; ..\CortexLib\Common\RomObject; Application\AdcDmaDataProvider; Application\AdcDmaDataProvider\Contracts; Application\DataRepository; Application\DataRepository\Contracts; Application\DigitalFilter; Application\DigitalFilter\Contracts; Application\Formatter; Application\Formatter\Contracts; Application\Leds; Application\Leds\Contracts; Application\Usart; Application\Usart\Contracts; Application\Voltage; Application\Voltage\Contracts; Tasks; Tasks\Contracts
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: Rtos; Rtos\FreeRtos; Rtos\FreeRtos\include; Rtos\FreeRtos\portable\IAR; Rtos\FreeRtos\portable\IAR\ARM_CM4F; Rtos\wrapper\FreeRtos; Rtos\wrapper
  OBJCOPY.OOCOutputFile: iarproject.srec
  ILINK.IlinkOutputFile: iarproject.out
  ILINK.IlinkIcfFile: stm32f411xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group (top)
    ./: main.cpp startupF411RE.cpp
  group AHardware/IrqController
    AHardware/IrqController/: irqcontroller.cpp
  group Application/AdcDmaDataProvider
    Application/AdcDmaDataProvider/: AdcDmaDataProvider.cpp AdcDmaDataProvider.hpp
  group Application/AdcDmaDataProvider/Contracts
    Application/AdcDmaDataProvider/Contracts/: IRawDataProvider.hpp
  group Application/DataRepository
    Application/DataRepository/: DataRepository.cpp DataRepository.hpp
  group Application/DataRepository/Contracts
    Application/DataRepository/Contracts/: IDataRepositoryProvider.hpp IDataRepositoryUpdater.hpp
  group Application/DigitalFilter
    Application/DigitalFilter/: DigitalFilter.hpp
  group Application/DigitalFilter/Contracts
    Application/DigitalFilter/Contracts/: IDigitalFilter.hpp
  group Application/Formatter
    Application/Formatter/: Formatter.cpp Formatter.hpp
  group Application/Formatter/Contracts
    Application/Formatter/Contracts/: IFormatter.hpp
  group Application/Leds
    Application/Leds/: LedCalculator.cpp LedCalculator.hpp LedController.cpp LedController.hpp
  group Application/Leds/Contracts
    Application/Leds/Contracts/: ILedCalculator.hpp ILedController.hpp
  group Application/Usart
    Application/Usart/: Usart.cpp Usart.hpp
  group Application/Usart/Contracts
    Application/Usart/Contracts/: IUsart.hpp
  group Application/Voltage
    Application/Voltage/: Voltage.hpp
  group Application/Voltage/Contracts
    Application/Voltage/Contracts/: IVoltage.hpp
  group Rtos/FreeRtos
    Rtos/FreeRtos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Rtos/FreeRtos/portable/Common
    Rtos/FreeRtos/portable/Common/: mpu_wrappers.c
  group Rtos/FreeRtos/portable/IAR/ARM_CM4F
    Rtos/FreeRtos/portable/IAR/ARM_CM4F/: port.c portasm.c portasm.s
  group Rtos/FreeRtos/portable/MemMang
    Rtos/FreeRtos/portable/MemMang/: heap_1.c
  group Rtos/wrapper/FreeRtos
    Rtos/wrapper/: criticalsection.hpp event.hpp eventmode.hpp interruptentry.hpp mailbox.hpp mutex.hpp rtos.hpp thread.hpp
  group Tasks
    Tasks/: MeasurementTask.cpp MeasurementTask.hpp
